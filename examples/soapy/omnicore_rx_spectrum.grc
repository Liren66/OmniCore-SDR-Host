options:
  parameters:
    description: OmniCoreSDR receive spectrum and waterfall through the SoapySDR module (docs/soapy.md)
    generate_options: qt_gui
    id: omnicore_rx_spectrum
    output_language: python
    title: OmniCoreSDR RX spectrum
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Frequency (Hz)
    start: 70e6
    step: 1e6
    stop: 6e9
    value: 1e9
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: Maximum 73 dB up to 1.3 GHz, 71 dB to 4 GHz, 62 dB above; the module clamps higher values
    gui_hint: 0,1,1,1
    label: RX gain (dB)
    start: '-3'
    step: '1'
    stop: '73'
    value: '30'
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    antenna1: RX
    center_freq0: freq
    center_freq1: freq
    comment: driver=omnicore. Bandwidth 0 keeps the current RF bandwidth.
    dc_removal0: 'False'
    dc_removal1: 'False'
    driver: omnicore
    gain0: gain
    gain1: gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: 1,0,1,2
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '2048'
    gui_hint: 2,0,1,2
    int_max: '-20'
    int_min: '-110'
    type: complex
  states: {}

connections:
- [soapy_custom_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_custom_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
